# IAR project PKT8S01_DEMO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\BSP; ..\LIB\inc; $PROJ_DIR$; ..\USR; ..\LIB; ..\BSP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PKT8S01_DEMO.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../BSP/: adc.c beep.c bspinit.c idog.c key_scan.c led.c spi.c tim1.c uart1.c w25x16.c
  group lib
    ../LIB/src/: stm8s_adc1.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_spi.c stm8s_tim1.c stm8s_uart1.c stm8s_wwdg.c
  group readme
    ../README/: introduce.txt
    ../: README.md
  group usr
    ../USR/: delay_time.c frames.c main.c stm8s_it.c
