<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>bsp</name>
    <file>
      <name>$PROJ_DIR$\..\BSP\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\bspinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\idog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\key_scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\BSP\w25x16.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_uart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LIB\src\stm8s_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>readme</name>
    <file>
      <name>$PROJ_DIR$\..\README\introduce.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\README.md</name>
    </file>
  </group>
  <group>
    <name>usr</name>
    <file>
      <name>$PROJ_DIR$\..\USR\delay_time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\frames.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USR\stm8s_it.c</name>
    </file>
  </group>
</project>


